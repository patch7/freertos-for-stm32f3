# IAR project freertos for stm32f3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: D:\Папка АНДРЕЯ\Программирование\project\freertos-for-stm32f303\CMSIS\Include; D:\Папка АНДРЕЯ\Программирование\project\freertos-for-stm32f303\CMSIS\STM32F30x\Include; D:\Папка АНДРЕЯ\Программирование\project\freertos-for-stm32f303\FreeRTOS\include; D:\Папка АНДРЕЯ\Программирование\project\freertos-for-stm32f303\STM32F30x_StdPeriph_Driver\inc; D:\Папка АНДРЕЯ\Программирование\project\freertos-for-stm32f303\FreeRTOS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: freertos for stm32f3.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS/include
    CMSIS/STM32F30x/Include/: stm32f30x.h stm32f30x_conf.h system_stm32f30x.h
  group CMSIS/source
    CMSIS/STM32F30x/Source/Templates/: system_stm32f30x.c
  group CMSIS/startup
    CMSIS/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
  group FreeRTOS
    FreeRTOS/: portasm.s
  group FreeRTOS/include
    FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ./: FreeRTOSConfig.h
  group FreeRTOS/source
    FreeRTOS/source/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group include
    STM32F30x_StdPeriph_Driver/inc/: stm32f30x_adc.h stm32f30x_can.h stm32f30x_comp.h stm32f30x_crc.h stm32f30x_dac.h stm32f30x_dbgmcu.h stm32f30x_dma.h stm32f30x_exti.h stm32f30x_flash.h stm32f30x_gpio.h stm32f30x_i2c.h stm32f30x_iwdg.h stm32f30x_misc.h stm32f30x_opamp.h stm32f30x_pwr.h stm32f30x_rcc.h stm32f30x_rtc.h stm32f30x_spi.h stm32f30x_syscfg.h stm32f30x_tim.h stm32f30x_usart.h stm32f30x_wwdg.h
  group source
    STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
