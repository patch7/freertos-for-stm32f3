<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\freertos for stm32f3.ewp</path>
  </project>
  <batchBuild/>
</workspace>


